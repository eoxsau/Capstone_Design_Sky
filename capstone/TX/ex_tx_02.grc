options:
  parameters:
    generate_options: qt_gui
    id: ex_tx_02
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: freq_1
  id: variable
  parameters:
    value: '0'
  states: {}
- name: samp_rate_1
  id: variable
  parameters:
    value: 20e6
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: freq_1
    offset: '0'
    phase: '0'
    samp_rate: samp_rate_1
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '1.0'
    type: complex
  states: {}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    args: '"hackrf=0"'
    bb_gain0: '20'
    freq0: 100e6
    gain0: '15'
    if_gain0: '20'
    sample_rate: samp_rate_1
    sync: sync
    type: fc32
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate_1
    fc: 100e6
    fftsize: '4096'
    type: complex
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', osmosdr_sink_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
